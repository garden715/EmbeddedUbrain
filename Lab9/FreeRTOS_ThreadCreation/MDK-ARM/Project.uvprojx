# Keil uVision project Project.uvprojx, settings and files
target STM324x9I_EVAL (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F429NI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM324x9I_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM324x9I_EVAL,
  c misc: --C99
  c include: ..\..\..\Drivers\BSP\Components;..\..\..\Utilities;..\..\..\Drivers\BSP\STM32F429II_HUINS;..\Inc;..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c
    ./: main-lab7.c
  group Docs
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
  group Drivers/BSP/STM324x9I_EVAL
    ../../../Drivers/BSP/STM32F429II_HUINS/: stm324x9i_eval.c stm324x9i_eval_io.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_sram.c stm32f4xx_ll_fmc.c stm32f4xx_hal_uart.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group Middlewares/FreeRTOS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/portable
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
